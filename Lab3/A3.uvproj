# Keil uVision project A3.uvproj, settings and files
target Aufgabenblatt 1 (166/167)
  device: XE164F-96F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE0FFFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xCBFFFF) CLOCK(20000000) MOD167 MODV2
  output: A3
  group Source Group 1
    ./: A3_1.a66 A3_2.a66 A3_3.a66 A3_4.a66
target Aufgabenblatt 2 (166/167)
  device: XE164F-96F Infineon
  cpu: as above
  output: A3
