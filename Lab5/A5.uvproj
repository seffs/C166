# Keil uVision project A5.uvproj, settings and files
target Target 1 (166/167)
  device: XE164F-96F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE0FFFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xCBFFFF) CLOCK(20000000) MOD167 MODV2
  output: A4
  group Source Group 1
    ./: START_V3.A66 Aufgabe_1.c Aufgabe_2.c t3power.c Aufgabe_3.c
